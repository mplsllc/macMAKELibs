/* Metrowerks Standard Library
 * Copyright © 1995-2002 Metrowerks Corporation.  All rights reserved.
 *
 * $Date: 2002/03/11 17:04:08 $
 * $Revision: 1.14.2.2 $
 */

/* $Id: math_x87.c,v 1.14.2.2 2002/03/11 17:04:08 jwankerl Exp $ */

#ifndef _INSIDE_K63D_C_

#include <ansi_parms.h>

#undef	_MSL_USE_INLINE
#define	_MSL_USE_INLINE 1
#undef	_MSL_INLINE
#define	_MSL_INLINE _MSL_DO_NOT_INLINE

#undef	_MSL_MATH_CDECL
#define	_MSL_MATH_CDECL __cdecl

/*	need to include this so we reference the correct version */
#include <ThreadLocalData.h>

/*	turn off all the options to generate plain old __cdecl code */
#pragma k63d off
#pragma sse off
#pragma sse2 off
#pragma inline_intrinsics off

#endif	/*_INSIDE_K63D_C_*/

#if 0
#pragma mark <cmath> function definitions
#endif

#include <cmath>

_MSL_BEGIN_NAMESPACE_STD
_MSL_BEGIN_EXTERN_C

#define	__HALF			dword ptr 0.5f

/* acos inlined */

/* acosh inlined */

/* asin inlined */

/* asinh inlined */

/* atan inlined */

/* atan2 inlined */

/* atanh inlined */

#if 0
_MSL_IMP_EXP_C  double      _MSL_MATH_CDECL cbrt(double x)
{
#error This function is not implemented.
}
#endif

/* ceil inlined */

/* copysign inlined */

/* cos inlined */

_MSL_IMP_EXP_C  double      _MSL_MATH_CDECL cosh(double x)
{
	asm
	{
		fld x
		fldl2e			; st=log2(e) st(1)=x
		fmul st,st(1)		; st=y=x*log2(e) 
		fld st			; pushes st into st(1),st(2)=garbage
		fst st(2)		; copies I+f to st(2)
		frndint			; st=I,st(1)=y will work only for round 
					; to nearest or maybe chop
		fxch			;; st=I+f  st(1)=I st(2)=I+f
		fsub st,st(1)		; st=f st(1)=I  st(2)=y=I+f
		fst st(2)
		f2xm1
		fld1
		fadd			; st=2^f st(1)=2^f -1 st(2)=I+f
		fscale			; st=2^f*2^I  st(1)=I st(2)=f

		fxch st(2)		; st=f st1=I st2=2^f
		fchs			; st=-f st1=I st2=2^f
		f2xm1
		fld1
		fadd			; st=2^-f st(1)=I  st(2)=2^f
		fxch
		fchs
		fxch
		fscale
		fstp st(1)		; st=2^-y st(1)=2^y st(2)=y
		fadd
		fld __HALF
		fmul
		fstp x
	}
	return x;
}


#if !__INTEL__
_MSL_IMP_EXP_C  double      _MSL_MATH_CDECL erf(double x)
{
#error This function is not implemented.
}
#endif

#if !__INTEL__
_MSL_IMP_EXP_C  double      _MSL_MATH_CDECL erfc(double x)
{
#error This function is not implemented.
}
#endif

/* exp inlined */

/* exp2 inlined */

/* expm1 inlined */

/* fabs inlined */

/* fdim inlined */

/* floor inlined */

#if 0
_MSL_IMP_EXP_C  double      _MSL_MATH_CDECL fma(double x, double y, double z)
{ return x*y+z; }

#endif

/* fmax inlined */

/* fmin inlined */

/* fmod inlined */

/* frexp inlined */

/* hypot inlined */

#if 0
_MSL_IMP_EXP_C  int         _MSL_MATH_CDECL ilogb(double x)
{
#error This function is not implemented.
}
#endif

/* ldexp inlined */

#if !__INTEL__
_MSL_IMP_EXP_C  double      _MSL_MATH_CDECL lgamma(double x)
{
#error This function is not implemented.
}
#endif

/* llrint inlined */

/* llround inlined */

/* log inlined */

/* log10 inlined */

/* log1p inlined */

/* log2 inlined */

/* logb inlined */

/* lrint inlined */

/* lround inlined */

/* modf inlined */

/* nan inlined */

/* nearbyint inlined */

#if !__INTEL__
_MSL_IMP_EXP_C  double      _MSL_MATH_CDECL nextafter(double x, double y)
{
#error This function is not implemented.
}
#endif

#if 0
_MSL_IMP_EXP_C  double      _MSL_MATH_CDECL nexttoward(double x, long double y)
{
#error This function is not implemented.
}
#endif

_MSL_IMP_EXP_C  double      _MSL_MATH_CDECL pow(double x, double y)
{
	short TEMP ;
	long  LONGTEMP;

	#define ONE		qword ptr 1.0
	#define HALF	qword ptr 0.5
	#define QNAN	dword ptr 0x7fffffff
	#define TRUNC	word ptr 0x0f7f

	if(x > 0)
	{ 
		asm
		{
			fld y
			fld x 
			fyl2x	        ; st=y*log2(x) overwrites st(1) and pops stack
			fld st	        ; backup I+f
			frndint	        ; st=I st(1)=y*log2(x)
			fxch
			fsub st,st(1)	; st(1)-st=st=f overwrites st(1)
			f2xm1
			fld1 
			fadd			; st=2^f st(1)=2^f-1 st(2)=I
			fscale
			fstp st(1)	
			fstp x
		}
		return x; 
	}
 
	if((x==0.0 && y <= 0) || (x < 0 && (rint(y) != y)))
	{
		errno=EDOM;
		if(x == 0.0 && y < 0.0) 
			return INFINITY ;
		else 
			return NAN ;
	}

	 /* if we're here we know the base is not positive and exponent integral */
 
	asm
	{
	 	fld y
	 	fld x 
		mov TEMP,1		   ; used at end
		ftst
		fstsw ax
		and ax,0x4000      ; c3=0 iff base (x) is zero(nan case taken care of by above)
	    			       ; zf=0 if base is zero
		jz negative_base
		mov TEMP, 0
		jmp zero_base
	negative_base:		; test for even or odd
		fxch
		fld st
		fistp LONGTEMP
		mov al, byte ptr[LONGTEMP]
	    test al,0x01
		fxch
		fchs			; base,exp combo legit so we change
					    ; sign of base to make it >0
		jz normal_pow
		mov TEMP,-1
	normal_pow:
		fyl2x			; st=y*log2(x) overwrites st(1) and pops stack
		fld st			; backup I+f
		frndint			; st=I st(1)=y*log2(x)
		fxch
		fsub st,st(1)	; st(1)-st=st=f overwrites st(1)
		f2xm1
		fld1 
		fadd			; st=2^f st(1)=2^f-1 st(2)=I
		fscale	
	zero_base:	
		fstp st(1)	
		fimul TEMP		; change sign of result if exponent is odd
		fstp x
	}
	
	#undef ONE
	#undef HALF
	#undef QNAN
	#undef TRUNC
	
	return x;
}

/* remainder inlined */

/* remquo inlined */

/* rint inlined */

/* round inlined */

/* scalbln inlined */

/* scalbn inlined */

/* sin inlined */

_MSL_IMP_EXP_C  double      _MSL_MATH_CDECL sinh(double x)
{
	asm
	{
		fld x
		fldl2e			; st=log2(e) st(1)=x
		fmul			; st=y=x*log2(e) st(1)=log2(e)
		fld st			; st=st(1)=y
		frndint			; st=I,st(1)=y will work only for round 
				; to nearest or maybe chop
		ftst			; if st=0 i.e. y is small -> we
		fnstsw ax
		sahf
		jnz big_y		; neednt do a fscale when I=0.
		fstp st			; pop stack(dont need I anymore I=0)
		fld st
		; fst st(1)		; st==st(1)=f (need a backup for -f)
		f2xm1
		fxch
		fchs
		f2xm1
		jmp common_sinh
		big_y:
		fxch
		fsub st,st(1)		; st=y st(1)=I  o.k. to bash y now

		fld st(1)		; st=st(1) st=stold st2=st1old
		fxch 	
		fst st(2)		; st=f=y-I st(1)=I st(2)=f
		f2xm1
		fld1
		fadd
		fscale			; st=2^f st(1)=I st(2)=f
		fxch st(2)		; st=f st1=I st2=2^f
		fchs			; st=-f st1=I st2=2^f
		f2xm1
		fld1
		fadd			; st=2^-f st(1)=I  st(2)=2^f
		fxch
		fchs
		fxch
		fscale
		fstp st(1)		; st=2^-y st(1)=2^y st(2)=y

		common_sinh:	
		fsub
		fld __HALF
		fmul
		fstp x
	}
	return x;
}

/* sqrt inlined */

/* tan inlined */

/* tanh inlined */

#if 0
_MSL_IMP_EXP_C  double      _MSL_MATH_CDECL tgamma(double x)
{
#error This function is not implemented.
}
#endif

/* trunc inlined */

_MSL_END_EXTERN_C
_MSL_END_NAMESPACE_STD

/* Change record: 
 * mf  980405 updated fmax,fmin,fdim to C9X to return a non-nan value when 
 *            exactly one argument is a nan.
 * mf  980420 fixed round and roundtol     
 * mf  980608 performance enhancements, __declspec(naked)
 *            whenever possible(shrinks codesize by about 10% when combined
 *            with other minor fixes(elimination of local variables etc.)  
 * mf  980610 fixed bug in acosh(was using fmul instead of fmul st,st(1)(i.e. was popping)				 
 * mf  980710 rewrote copysign
 * mf  980713 bug in asinh(wasn't restoring ebp)
 * mf  981113 log10 wasn't poping argument from fp stack when errno occured
 * mf  990721 fixed bug in fmin(IR9907-1375)(completely rewrote fmin/max/dim
 *            math_wrapper.c routines were sharing an unprotected/volitale static(TEMP).  
 *            Each routine now has it's own local to make it threadsafe.  
 *            Fixed bug in expm1 as reported by Fred Tydeman.
 * mf  990828 temporary workaround to compiler bug--
 *            removed const designation from LOG_ONEPX_MAX
 * mf  991007 fixed bug in round introduced w/threadsafe fix. 
 *            removed workaround in previous note.
 * pmk 010404 moved math_wrapper.obj into math_wrapper.c
 * cc  011115 Added defines to new inline flags
 * ejs 020124 Moved math_wrapper.c to math_x87.c, added remaining functions
 * ejs 020222 Exclude intrinsic functions from inlining.
 * JWW 020308 Use new _MSL_DO_NOT_INLINE macro for bringing inlined functions into the library
 */
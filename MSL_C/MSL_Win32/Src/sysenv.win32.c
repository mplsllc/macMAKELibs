/* Metrowerks Standard Library
 * Copyright © 1995-2002 Metrowerks Corporation.  All rights reserved.
 *
 * $Date: 2002/02/04 21:24:09 $
 * $Revision: 1.23 $
 */
 
/*
 *	Routines
 *	--------
 *		_SetupEnv
 *		getenv
 *		_putenv
 *		system
 *
 */

#include <crtl.h>   			
#include <stdlib.h>				
#include <extras.h>				/*- cc 000512 -*/
#include <errno.h>  				
#include <string.h>  
#include <file_io.h>
#include <sysenv_api.h>

/*	
	Array of environment variables in the form "variable=value",
	case-insensitively sorted by variable.

	_environ_length does not include the trailing NULL.
*/
char **_environ;
size_t _environ_length;
static size_t _environ_max;
#define ENVIRON_GROW 16

#if ( __dest_os==__wince_os)

void _SetupEnv(void)
{
}

char * _MSL_CDECL getenv(const char * /*inVarName*/)
{
	return 0;
}

#else	// not wince
#pragma mark -

/*
 *	Unlike __msl_strnicmp, the environment is sorted by uppercase comparisons,
 *	so variables starting with '_' are at the end of the sort order.
 *	Also, we stop at '=' or end-of-string.
 */
static int __env_stricmp(const char *s1, const char *s2)
{
	char c1, c2;
	int equ=1;
	while (1)
	{
		c1 = toupper(*s1++);
		c2 = toupper(*s2++);
		if (c1 != c2) break;
		if (!c1 || c1=='=') return 0;
	}
	if (c1 == '=') c1 = 0;
	if (c2 == '=') c2 = 0;
	if (c1 == c2) return 0;
	return c1 - c2;
}


/*
 * 	create _environ array
 */
static void init_environ(char *envblock)
{
	char *ptr;

	_environ_length = 0;
	_environ_max = _environ_length + ENVIRON_GROW;
	_environ = (char **)malloc((_environ_max) * sizeof(char *));
	_environ[0] = 0L;
	
	/* 	Add each entry to our sorted array (the incoming environment
		may LOOK sorted, but it's not guaranteed to be) */
	ptr = envblock;
	while (*ptr)
	{
		/* ignore current directory */
		if (*ptr != '=')
			__msl_putenv(ptr);
		ptr += strlen(ptr) + 1;
	}
}

#define CHUNK(val, sz) \
	((( (val) + (sz) - 1 ) / (sz)) * (sz))
	
static void resize_environ(size_t length)
{
	size_t oldmax = _environ_max;
	
	_environ_max = CHUNK(length+1, ENVIRON_GROW);
	if (_environ_max != oldmax)
	{
		_environ = realloc(_environ, sizeof(char *) * _environ_max);
	}
	_environ_length = length;
}

/*
	Initialize environment strings block.
	
	Windows manages environment strings for us, but only provides ways to
	read a variable, set a variable, and get the entire block of strings.
	Windows/DOS programs want to manipulate an _environ array instead
*/
void _MSL_CDECL _SetupEnv(void)
{
    char *theEnvStrings;

	/* Get original environment variable string block */
	theEnvStrings = GetEnvironmentStrings();

	/* Add its vars... */
	init_environ(theEnvStrings);
	
	/* Release to Windows */
	FreeEnvironmentStrings(theEnvStrings);
}

/*
 *	Lookup an environment variable.  We maintain _environ in sorted order.
 *	Return the pointer and the index of the variable,
 *	or return NULL and the insertion index.
 */
static char *search_env(const char *inVarName, int *index)
{
	char *ptr;
	int theVarNameLength = strlen(inVarName);
	int Min, Max;
	int StrInx = 0;
	int cmp = -1;
	
	Min = 0; Max = _environ_length - 1;
	while (Min <= Max)
	{
		StrInx = (Min + Max) >> 1;
		ptr = _environ[StrInx];

		cmp = __env_stricmp(inVarName, ptr);
		if (cmp == 0)
		{
			/* The string matches. Return a pointer to the value. */
			*index = StrInx;
			return ptr;
		}
		else if (cmp < 0)
		{
			Max = StrInx - 1;
		}
		else
		{
			Min = StrInx + 1;
		}
	}
	*index = cmp < 0 ? StrInx : StrInx+1;
	return 0L;
}

char * _MSL_CDECL getenv(const char * inVarName)
{
	char *ptr;
	int StrInx = 0;
	int theVarNameLength = strlen(inVarName);

	if ((ptr = search_env(inVarName, &StrInx)))
		return ptr + theVarNameLength + 1;
	else
		return 0L;
}

/*
 *	Update the environment strings.
 *
 *	To define a new variable or redefine an old one: "varname=value";
 *	to delete a variable: "varname=".
 *
 *	We keep the strings in sorted order.
 */
int _MSL_CDECL __msl_putenv(const char * varSetting)
{
	/* scan the incoming string for the variable name and its value */
	const char *equal_sign = strchr(varSetting, '=');

	if (equal_sign)
	{
		/* isolate variable and argument */
		int var_length = equal_sign - varSetting;
		const char *arg = equal_sign + 1;
		int index;
		int edelta;
		
		/* 	scan for location to write new variable */
		if (search_env(varSetting, &index))
		{
			/* found existing element */
			if (!*arg)
			{
				/* if defining to "", remove entry */
				edelta = -1;
				varSetting = 0L;
			}
			else
			{
				/* replace entry */
				edelta = 0;
			}
			free(_environ[index]);
		}
		else if (*arg)
		{
			/* defining new string */
			edelta = 1;
		}
		else
		{
			/* deleting undefined variable */
			return 0;
		}
			
		/* resize environ */
		if (edelta < 0)
		{
			memmove(&_environ[index], &_environ[index+1], (_environ_length - index) * sizeof(char *));
			resize_environ(_environ_length + edelta);
		}
		else if (edelta > 0)
		{
			resize_environ(_environ_length + edelta);
			memmove(&_environ[index+1], &_environ[index], (_environ_length - index) * sizeof(char *));
		}
		
		/* copy in new string */
		if (varSetting)
		{
			_environ[index] = __msl_strdup(varSetting);
		}
	}
	else
	{
		/* error: malformed argument */
		return -1;	
	}

	return 0;	/* success */
}

#endif	// wince!

#pragma mark -

/*
	Get the command processor
*/
static const char *get_comspec(void)
{
	const char *comspec = getenv("COMSPEC");
	
	if (!comspec)
	{
		/* 	fallback if COMSPEC is not set -- 
			get assumed command processor based on Windows version */
		OSVERSIONINFO osvi;
		
		osvi.dwOSVersionInfoSize = sizeof(OSVERSIONINFO);
		
		if (GetVersionEx (&osvi))
		{
			switch (osvi.dwPlatformId)
			{
			case VER_PLATFORM_WIN32_NT:
				comspec = "cmd.exe";
				break;

			case VER_PLATFORM_WIN32s:
			case VER_PLATFORM_WIN32_WINDOWS:
				comspec = "command.com";
				break;
			}
		}
	}
	
	return comspec;
}

/*
 *	Get a copy of the environment block.
 */
static char *get_envblock(const char *const *envp)
{
	int i;
	int len = 0;
	char *block, *ptr;
	char curdir[_MAX_PATH];
	
	/* count total length */
	for (i = 0; envp[i]; i++)
		len += strlen(envp[i]) + 1;
	
	/* current directory */
	if (!GetCurrentDirectory(sizeof(curdir)-4, curdir+4)) 
		*curdir = 0;
	else
	{
		curdir[0] = '=';
		curdir[1] = curdir[3];
		curdir[2] = ':';
		curdir[3] = '=';
		len += strlen(curdir) + 1;
	}
	
	/* terminator */
	len++;
	
	block = malloc(sizeof(char) * len);
	if (!block) {
		errno = ENOMEM;
		return 0L;
	}
	
	/* copy each string consecutively */
	ptr = block;

	/* copy current directory */
	if (*curdir)
	{
		len = strlen(curdir) + 1;
		memcpy(ptr, curdir, len);
		ptr += len;
	}
	
	for (i = 0; envp[i]; i++)
	{
		len = strlen(envp[i]) + 1;
		memcpy(ptr, envp[i], len);
		ptr += len;
	}
	
	/* terminate block with null string */
	*ptr = 0;
	
	return block;
}


/*
	Execute 'cmdLine' in a process created with crFlags, 
	and return process information in piProcInfo. 
	
	Returns 0 for success, -1 for failure
*/
int _MSL_CDECL __msl_system_core(const char *comspec, const char * cmdLine, const char *const *envp,
						DWORD crFlags, PROCESS_INFORMATION *piProcInfo)
{
	int result = 0;
	STARTUPINFO	siStartInfo;
	char *		real_cmdLine; 					/*- cc 000609 -*/
	char *		envblock;
		
	/* construct full command line for Windows */
	if (comspec)
	{
		/* pass "%COMSPEC% /c cmdline" */
		real_cmdLine = malloc(strlen(comspec) + 4 + strlen(cmdLine) + 1);
		if (!real_cmdLine)											/*- cc 001113 -*/
		{
			errno = ENOMEM;
			return ERROR_OUTOFMEMORY;
		}
		
		strcpy(real_cmdLine, comspec);
		strcat(real_cmdLine, " /c ");  	/*- cc 000609 -*/
		strcat(real_cmdLine, cmdLine);	/*- cc 000609 -*/
	}
	else
	{
		/* just run "cmdline" */
		real_cmdLine = malloc(strlen(cmdLine) + 1);
		if (!real_cmdLine)											/*- cc 001113 -*/
		{
			errno = ENOMEM;
			return ERROR_OUTOFMEMORY;
		}
		
		strcpy(real_cmdLine, cmdLine);
	}

	/* Create environment block */
	envblock = get_envblock(envp ? envp : _environ);
	
	/* Create the child process. */ 
    memset(&siStartInfo,0,sizeof(siStartInfo));
    siStartInfo.cb = sizeof(siStartInfo);
	siStartInfo.hStdInput = GetStdHandle(STD_INPUT_HANDLE);
	siStartInfo.hStdOutput = GetStdHandle(STD_OUTPUT_HANDLE);
	siStartInfo.hStdError = GetStdHandle(STD_ERROR_HANDLE);

	result = CreateProcess(	NULL,				/* application name */
							real_cmdLine,		/* command line */ /*- cc 001113 -*/
							NULL,				/* process security attributes */
							NULL,				/* primary thread security attributes */
							TRUE,				/* handles are inherited */
							crFlags,			/* creation flags */ /*- ejs 011116 -*/
							envblock,			/* use current environment */
							NULL,				/* working directory path */
							&siStartInfo,		/* STARTUPINFO pointer */
							piProcInfo);		/* receives PROCESS_INFORMATION */

	/* store error result */
	if (!result)
		__set_errno(GetLastError());
	else
		errno = _doserrno = 0;

	/* release memory allocated for environment block */
	free(envblock);
	free(real_cmdLine);/*- cc 001113 -*/

	return result ? 0 : -1;
}

int _MSL_CDECL system(const char *cmdLine)
{
	const char *comspec;
	
	/* get command processor */		
	comspec = get_comspec();
	
	/* 	if cmdLine is NULL, ANSI C says check the existence of the command processor,
		returning 1 if found, 0 otherwise.  Note, this fails if COMSPEC is not set,
		unless the shell lives in the current directory, since comspec is not a full path. */
	if (!cmdLine)
	{
		return comspec && GetFileAttributes(comspec) != 0xFFFFFFFF;
	}
	else
	{
		PROCESS_INFORMATION piProcInfo;
		DWORD exitcode;
		
		/* else launch the program and wait for it to complete. */
		if(__msl_system_core(comspec, cmdLine, 0, 0, &piProcInfo) == 0)
		{
			WaitForSingleObject(piProcInfo.hProcess, INFINITE); 
			GetExitCodeProcess(piProcInfo.hProcess, &exitcode);
			CloseHandle(piProcInfo.hProcess);
			CloseHandle(piProcInfo.hThread);
			return exitcode;
		} 
		else 
		{
			return -1;
		}
	}
}

/* Change record:
 * KO  961211 Wrote this file.
 * mm  990115 Rewrote getenv() to make use of _environ
 * vss 990121 Moved system function to sysenv.c
 * mm  990125 Change to allow compilation without warning message
 * blc 990922 Added _putenv, modified system to use runtime environment
 * cc  000221 Added errno.h 
 * cc  000512 Added #include<extras.h>
 * cc  000609 Changed system to take in path to shell plus commmand line
 * cc  000612 Added case for Win2000 shell
 * cc  001113 Added fix so the value of COMSPEC will not be overwritten
 * cc  001113 Added free(real_cmdLine)
 * cc  010605 Moved _putenv to extras.win32.c
 * cc  010605 Made calls equal to _strnicmp call __msl_strnicmp & added #include 
 *			  file_io.h
 * ejs 011116 Rewrote system()
 * ejs 011119 Rewrote environment handling code
 * cc  011203 Added _MSL_CDECL for new name mangling 
 */